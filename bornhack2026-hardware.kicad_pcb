# Repository badgeteam/bornhack2026-hardware

File readme.md:

# Cyber Ægg

## Introduction

The badge is intended to be a low power LoRa device, that should be able to at least run for the whole duration of the BornHack camp on one battery charge (One week).
At least that is one of our design goals, lot's of hours chasing down power use in both the hardware and the software are still ahead of us, when measurements have been done I'll share them in the Badge.Team Discord.

At this moment the design is at prototype stage one, and is not fully developed.

For example the NFC, LoRa and Bluetooth circuits still have IPEX connectors integrated to make tuning the circuits easier.

Also certain aspects, especially the on PCB antennas should at least work, but how well, we do not know yet.

Long story short, consider this design BETA, and do not order your own boards yet. (Or if you do, you are on your own.)

## Functionality

The is designed with MeshCore in mind, to connect up to a smart phone using Bluetooth and connect to the greater MeshCore network using the on PCB LoRa circuit.

To provide some extra camp fun, we hope the communication technologies combined with the NFC tag functionality will result in some really cool location based games that will run on the badge.
For now the game ideas being worked out, and it's up to the game team of BornHack what they share.

### Display

For now the e-paper display is designed in from SWI, model number: SG0154BNS800F35HP

The display has a 1.54Inch size with 152x152 pixels.

These displays have the [SSD1680Z8](https://cdn-learn.adafruit.com/assets/assets/000/097/631/original/SSD1680_Datasheet.pdf?1607625960) controller controller IC.

### Manual input

Because the Cyber Ægg badge is inspired by the 90's Tamagotchi egg shaped game, the buttons are named the same.

| button name | function                          |
| ----------- | --------------------------------- |
| Select      | Navigate through the menu options |
| Execute     | Start the option under the cursor |
| Cancel      | Cancel current operation          |

In order to make navigation a more intuitive, the select button has been upgraded to a joystick + button.

### Bluetooth

The Bluetooth implementation on this board is provided by the NRF52840 MCU.
Texas instruments has released a design for a 2.4GHz antenna, the antenna is provided as a Footprint included with Kicad 9.0.

#### BlueTooth Antenna

Bluetooth is using 2.4GHz, and a PCB antenna suitable for this frequency band is integrated into the PCB.
The design used is available in KiCAD 9 in the standard library and is originally by Texas instruments.

The documentation for the antenna can be found here : [swra228.pdf](https://www.ti.com/lit/an/swra228c/swra228c.pdf)

### LoRa

LoRa is provided by a separate SX1262 IC, with a tuning circuit as specified by the data sheet and implementation notes provided by Semtech.

The document that specifies the layout/balun/matching circuit for the sx1262 is named *"AN1200.54"* and can be found at [this page](https://www.semtech.com/products/wireless-rf/lora-connect/sx1261)

#### Lora Antenna

The LoRa antenna is also a Texas instruments design, the specifications can be found here [swra416](https://www.ti.com/lit/an/swra416/swra416.pdf)

### NFC

NRF is again provided by a PHY in the NRF82840 core, which drives a resonant circuit consisting of 2 (eventually) capacitors, and a CPB coil.

The NRF52840 only supports TAG functionality no reader functionality.

The coil in this design has a inductance of around 2.8uH, which together with the capacitors and the paracytics (both capacitance and inductance) should form a tank circuit that matches the 13.56MHz for interacting with an NRC reader.

### QWIIC

The QWIIC port is a standardized connector utilizing I2C, it's included on the badge because many boards have been produced for this [standard](https://www.sparkfun.com/qwiic) setup by Sparkfun.

Pins used for the SDA and SCL pins are listed below.

Two 10k pull up resistors are provided on the board, when the capacitance is too high on the I2C lines, the internal pull-ups can also be enabled (the provide an extra 10k pull-up resistance).

## Pinout

| Ball (aQFN73) | nRF pin      | Pin type(s)              | Project net  | Project function                                         |
| :------------ | :----------- | :----------------------- | :----------- | :------------------------------------------------------- |
| A12           | P0.02 AIN0   | Digital I/O Analog input | LED_BLUE     | LED blue (active low, GPIO output)                       |
| B13           | P0.03 AIN1   | Digital I/O Analog input | LORA_MISO    | LoRa (SX1262) SPI MISO (GPIO input)                      |
| J1            | P0.04 AIN2   | Digital I/O Analog input | LORA_RF_SW   | LoRa RF switch control (GPIO output)                     |
| K2            | P0.05 AIN3   | Digital I/O Analog input | BAT_CHARGE   | Charge status: low when charging (GPIO input)            |
| L1            | P0.06        | Digital I/O              | BTN_CANCEL   | Button: cancel (active low, GPIO input)                  |
| M2            | P0.07        | Digital I/O              | BAT_V_READ   | Battery read enable: pull low to read VBAT (GPIO output) |
| N1            | P0.08        | Digital I/O              | EPD_SCK      | EPD (SDD1680) SPI SCK (GPIO output)                      |
| M24           | P0.09 NFC1   | NFC I/O                  | NFC1         | NFC antenna connection                                   |
| L24           | P0.10 NFC2   | NFC I/O                  | NFC2         | NFC antenna connection                                   |
| U1            | P0.11        | Digital I/O              | EPD_RESET    | EPD (SDD1680) reset (GPIO output)                        |
| V2            | P0.12        | Digital I/O              | EPD_DC       | EPD (SDD1680) data/command (GPIO output)                 |
| W1            | P0.13        | Digital I/O              | BUZZER       | Buzzer square wave output (PWM/GPIO output)              |
| X2            | P0.14        | Digital I/O              | EPD_BUSY     | EPD (SDD1680) busy signal (GPIO input)                   |
| AC12          | P0.15        | Digital I/O              | GPIO_1       | General purpose I/O 1                                    |
| AB13          | P0.16        | Digital I/O              | GPIO_2       | General purpose I/O 2                                    |
| AC11          | P0.17        | Digital O                | PS_SYNC      | Power mode buck/boost hi/low power mode                  |
| AC13          | P0.18 nRESET | Digital O                | MCU_RESET    | nRESET (active low)                                      |
| AB11          | P0.19        | Digital I/O              | GPIO_3       | General purpose I/O 3                                    |
| AC9           | P0.20        | Digital I/O (QSPI)       | FLASH_IO0    | QSPI Flash IO0/D0                                        |
| AB9           | P0.21        | Digital I/O (QSPI)       | FLASH_SCK    | QSPI Flash clock (GPIO output)                           |
| AC7           | P0.22        | Digital I/O (QSPI)       | FLASH_IO2    | QSPI Flash IO2/D2                                        |
| AB7           | P0.23        | Digital I/O (QSPI)       | FLASH_IO3    | QSPI Flash IO3/D3                                        |
| AC5           | P0.24        | Digital I/O (QSPI)       | FLASH_IO1    | QSPI Flash IO1/D1                                        |
| AB5           | P0.25        | Digital I/O (QSPI)       | FLASH_CSN    | QSPI Flash chip select (active low, GPIO output)         |
| G1            | P0.26        | Digital I/O              | BTN_EXECUTE  | Button: execute (active low, GPIO input)                 |
| H2            | P0.27        | Digital I/O              | EPD_MOSI     | EPD (SDD1680) SPI MOSI (GPIO output)                     |
| B11           | P0.28 AIN4   | Digital I/O Analog input | LORA_BUSY    | LoRa (SX1262) busy (GPIO input)                          |
| A10           | P0.29 AIN5   | Digital I/O Analog input | LORA_DIO1    | LoRa (SX1262) DIO1 IRQ (GPIO input)                      |
| B9            | P0.30 AIN6   | Digital I/O Analog input | LORA_RST     | LoRa (SX1262) reset (GPIO output)                        |
| A8            | P0.31 AIN7   | Digital I/O Analog input | VBAT_V       | Battery voltage sense (ADC input)                        |
| AD22          | P1.00        | SWD                      | P1.00_SWO    | SWO pin SWD NRF52840                                     |
| Y23           | P1.01        | Digital I/O              | JOY_RIGHT    | Joystick: right (active low, GPIO input)                 |
| W24           | P1.02        | Digital I/O              | JOY_FIRE     | Joystick: fire (active low, GPIO input)                  |
| V24           | P1.03        | Digital I/O              | JOY_DOWN     | Joystick: down (active low, GPIO input)                  |
| U24           | P1.04        | Digital I/O              | JOY_UP       | Joystick: up (active low, GPIO input)                    |
| T23           | P1.05        | Digital I/O              | JOY_LEFT     | Joystick: left (active low, GPIO input)                  |
| P23           | P1.07        | Digital I/O              | LED_RED      | LED red (active low, GPIO output)                        |
| P2            | P1.08        | Digital I/O              | GPIO_4       | General purpose I/O 4                                    |
| R1            | P1.09        | Digital I/O              | EPD_CSN      | EPD (SDD1680) SPI CSN (active low, GPIO output)          |
| A20           | P1.10        | Digital I/O              | QWIIC_SDA    | Qwiic I²C SDA (open-drain)                               |
| B19           | P1.11        | Digital I/O              | QWIIC_SCL    | Qwiic I²C SCL (open-drain)                               |
| B17           | P1.12        | Digital I/O              | LORA_NSS     | LoRa (SX1262) SPI NSS/CS (active low, GPIO output)       |
| A16           | P1.13        | Digital I/O              | LORA_SCK     | LoRa (SX1262) SPI SCK (GPIO output)                      |
| B15           | P1.14        | Digital I/O              | LORA_MOSI    | LoRa (SX1262) SPI MOSI (GPIO output)                     |
| A14           | P1.15        | Digital I/O              | LED_GREEN    | LED green (active low, GPIO output)                      |
| AD6           | D+           | USB                      | USB_D+       | USB data +                                               |
| AD4           | D-           | USB                      | USB_D-       | USB data -                                               |

## 3D model export

The badge's full 3D model is available as a glTF binary (`.glb`) and a Collada
(`.dae`). Both are *generated* from the PCB - they are not checked in (see
`.gitignore`) - so regenerate them whenever the layout changes.

KiCad has no DAE/Collada export target, and Blender 5.0 dropped its own native
Collada exporter (`bpy.ops.wm.collada_export` is now a non-functional stub). So
we go in two steps:

1. **PCB -> GLB** with `kicad-cli` (KiCad 10 exports GLB natively).
2. **GLB -> DAE** inside Blender, importing the GLB and writing the Collada file
   with [`pycollada`](https://pypi.org/project/pycollada/) (a pure-Python
   library, so it loads on top of Blender's bundled numpy with no compiled
   extensions and no changes to your Blender install).

### Usage

One command, from anywhere in the repo:

```sh
tools/export-3d.sh
```

This writes `bornhack2026-hardware.glb` and `bornhack2026-hardware.dae` to the
repo root and prints their final paths and sizes. To convert a different board,
pass it as the first argument: `tools/export-3d.sh path/to/other.kicad_pcb`.

### Prerequisites

- **KiCad 10** (`kicad-cli` on your `PATH`).
- **Blender >= 4** (it ships its own Python 3.11+ / 5.0 ships 3.13). The script
  finds `blender`, `blender-5.0`, `blender-4.5`, etc. on your `PATH`, and on
  macOS also probes `/Applications/Blender.app`.
- **python3** to create a small throwaway venv for `pycollada`. On Debian/Ubuntu
  this means the `python3-venv` package.
- **Network access on the first run only**, so that venv can `pip install`
  `pycollada` (pinned for reproducibility). Subsequent runs reuse the cached venv.

You can override the autodetection with environment variables if needed:
`KICAD_CLI`, `BLENDER`, `KICAD9_3DMODEL_DIR`, `VENV_DIR`, and `OUTDIR`.

### Notes

- The generated `.glb` / `.dae` files and the tooling venv (`tools/.venv-3d/`)
  are git-ignored - they are large and fully regenerable.
- During the GLB export KiCad warns that the `FPC1` and `L1` component models are
  missing. That is **expected and harmless**: those two footprints are not in the
  standard KiCad 3D model library, so they simply do not appear in the model.

## KiCad design bornhack2026-hardware.kicad_pcb

Parts:
AE3: Antenna_Dipole; Texas_SWRA416_868MHz_915MHz_right_v2; not fitted
H1, H2, H3: MountingHole_Pad; MountingHole_2.2mm_M2_DIN965_Pad; not fitted
J1: USB device; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
J2: Conn_01x07_Pin; PinHeader_1x07_P1.00mm_Vertical_SMD_Pin1Left; not fitted
N1: Board edge + art; white-egg-svg2shenzhen; not fitted
N2: Badge.Team; stamp; not fitted
N3: Bornhack; bornhack-logo-10mm; not fitted
N4: Egg edge silk; egg-edge-silk; not fitted
N5: Bornhack Front; bornhack-logo-10mm; not fitted
R1, R2: 5k1; R_0402_1005Metric; LCSC C25905
R24: 1k; R_0402_1005Metric; LCSC C11702

Connections:
+3V3: J2.6; also elsewhere on the board
/CC1: J1.A5 (CC1), R1.2
/CC2: J1.B5 (CC2), R2.2
/EPD_MOSI: R24.2; also elsewhere on the board
/GPIO_1: J2.2; also elsewhere on the board
/GPIO_2: J2.3; also elsewhere on the board
/GPIO_3: J2.4; also elsewhere on the board
/GPIO_4: J2.5, R24.1; also elsewhere on the board
/SX1262 LoRA/LORA_ANT: AE3.1 (A_1); also elsewhere on the board
/USB_D+: J1.A6 (D+), J1.B6 (D+); also elsewhere on the board
/USB_D-: J1.A7 (D-), J1.B7 (D-); also elsewhere on the board
GND: H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.1, J2.7, R1.1, R2.1; also elsewhere on the board
VBUS: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS); also elsewhere on the board

Notes on the sheet:
TODO: wire to display!
JLCPCB Inpedance control Stackup used: JLC04161H-7628 Stackup Impendance calculator: https://jlcpcb.com/pcb-impedance-calculator
LED it be
Expansion port

Parts:
C62, C63, C64, C69, C70: 100nF; C_0402_1005Metric; LCSC C1525
C72: 1uF; C_0603_1608Metric; LCSC C5199872
R15: 47k; R_0402_1005Metric; LCSC C25792
R18, R22, R23, R27, R28: 10k; R_0402_1005Metric; LCSC C25744
SW1: RESET; SW-SMD_4P-L5.1-W5.1-P3.70-LS6.5-TL_H1.5; LCSC Part C318884
SW4: 7*7*5-6P WX; SW-SMD_6P-L7.0-W7.0-P1.40-LS7.4-TL; LCSC C2858286
TP11: TestPoint; TestPoint_Pad_1.0x1.0mm; not fitted

Connections:
+3V3: R15.1, R18.1, R22.1, R23.1, R27.1, R28.1; also elsewhere on the board
/JOY_DOWN: C62.2, R18.2, SW4.4; also elsewhere on the board
/JOY_FIRE: C63.2, R22.2, SW4.5; also elsewhere on the board
/JOY_LEFT: C69.2, R23.2, SW4.3; also elsewhere on the board
/JOY_RIGHT: C64.2, R27.2, SW4.6; also elsewhere on the board
/JOY_UP: C70.2, R28.2, SW4.1; also elsewhere on the board
/MCU_RESETn: C72.2, R15.2, SW1.2 (B), TP11.1 (1_1); also elsewhere on the board
GND: C62.1, C63.1, C64.1, C69.1, C70.1, C72.1, SW1.3 (C), SW4.2, SW4.7, SW4.8; also elsewhere on the board

Notes on the sheet:
https://jlcpcb.com/partdetail/ALPSALPINE-SKPMAME010/C115348 Betere knop
Based On Tamagotchi Buttons: https://www.jnlgame.com/cdn/shop/files/81tR9PHvDtL._AC_SL1500.jpg?v=1702227711&width=5760
https://jlcpcb.com/partdetail/ALPSALPINE-SKRHABE010/C139794 knoppen

Parts:
C9, C54, C56: 10uF; C_0603_1608Metric; LCSC C19702
C19, C57: 22uF; C_0603_1608Metric; LCSC C59461
C55: 100nF; C_0402_1005Metric; LCSC C1525
C66, C67: 2.2uF; C_0402_1005Metric; LCSC C12530
D6, D7: 1N5819WS; D_SOD-323; LCSC C191023
L1: 0.47uH A-sat 5.4 DCR 7.6 mOhm; L_Vishay_IFSC-1515AH_4x4x1.8mm; LCSC C7497069
Q1: JSM2301S; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; LCSC Part C916399
R5: 100k; R_0402_1005Metric; LCSC C25741
R14, R16: 1k; R_0402_1005Metric; LCSC C11702
R20: 3.3k; R_0402_1005Metric; LCSC C25890
R25: 2k; R_0402_1005Metric; LCSC C4109
R26: 10k; R_0402_1005Metric; LCSC C25744
R34, R44: 1M; R_0402_1005Metric; LCSC C26083
R35: 510k; R_0402_1005Metric; LCSC C25564
R45: 511k; R_0402_1005Metric; LCSC C64042
R46: 91k; R_0402_1005Metric; LCSC C4147
SW3: MS-22D28-G020; SW-SMD_MS-22D28-G020; LCSC Part C963205
TP5, TP6, TP7, TP8, TP9, TP10, TP12, TP13: TestPoint; TestPoint_Pad_1.0x1.0mm; not fitted
U1: PH-2AWB; CONN-SMD_PH-2AWB; LCSC Part C20598817
U4: XT4054K421MR-G; SOT-23-5_L2.9-W1.6-P0.95-LS2.8-BL; LCSC C141405
U10: TPS63805YFFR; DSBGA-15_L2.3-W1.3-R5-C3-P0.40-TL; LCSC Part C2879615

Connections:
+3V3: C19.1, C57.1, R26.2, R45.1, U10.E2 (VOUT), U10.E3 (VOUT); also elsewhere on the board
/BAT_CHARGE: R26.1, U4.1 (STAT); also elsewhere on the board
/MCU_RESETn: R20.2; also elsewhere on the board
/PS_SYNC: R44.2, TP13.1 (1_1), U10.B1 (MODE); also elsewhere on the board
BAT_V: R34.1, R35.2; also elsewhere on the board
BAT_V_READ: R35.1; also elsewhere on the board
GND: C9.2, C19.2, C54.1, C55.1, C56.2, C57.2, R5.2, R16.1, R25.1, R46.2, SW3.4, SW3.5, SW3.6, TP6.1 (1_1), TP8.1 (1_1), TP10.1 (1_1), U1.2, U1.3, U1.4, U4.2 (VSS), U10.C1 (AGND), U10.C2 (GND), U10.C3 (GND); also elsewhere on the board
unnamed: C67.2, R16.2, SW3.1
unnamed: C54.2, C55.2, D7.1 (K), U4.4 (VDD)
unnamed: L1.1, U10.D2 (L2), U10.D3 (L2)
unnamed: L1.2, U10.B2 (L1), U10.B3 (L1)
unnamed: C56.1, Q1.3 (D), R34.2, TP5.1 (1_1), U1.1, U4.3 (VBAT)
unnamed: R14.2, SW3.3
unnamed: R25.2, U4.5 (PROG)
unnamed: C66.2, C67.1, SW3.2, U10.A1 (EN)
unnamed: R45.2, R46.1, U10.D1 (FB)
unnamed: R20.1, TP12.1 (1_1), U10.E1 (PG)
VBUS: D6.2 (A), D7.2 (A), Q1.1 (G), R5.1, TP7.1 (1_1); also elsewhere on the board
VIN: C9.1, C66.1, D6.1 (K), Q1.2 (S), R14.1, R44.1, TP9.1 (1_1), U10.A2 (VIN), U10.A3 (VIN)

Notes on the sheet:
CHARGING is an open-drain output that gets pulled low when the charger is active (charging the battery)
Max 1mA sink on PG pin
IBAT = (1 / 2000) * 1000 = 500mA
3.3v DC/DC
Battery & battery charger
Battery connector
VIN: Range between VBAT and VBUS, 3.0 and 5.5V Absolete max 6.0V 3V3_OUT: Stabilized 3V3 using BUCK boost converter VBUS: Between 0 and 5.5V, directly from the USB-C connector
place close to TPS63805YFFR
R25 = R_PROG VPROG = 1V (constant current charging) IBAT = (1v/2k)*1000 = 0.5A

Parts:
R42, R43: 4.7k; R_0402_1005Metric; LCSC C25900
U8: HCZZ0032-4; CONN-SMD_HCZZ0032-4; LCSC Part C7433425
U9: USBLC6-2P6; SOT-666; LCSC C22390016

Connections:
+3V3: R42.2, R43.2, U8.2, U9.5 (VBUS); also elsewhere on the board
/QWIIC_SCL: R43.1, U9.4 (I/O2); also elsewhere on the board
/QWIIC_SDA: R42.1, U9.6 (I/O1); also elsewhere on the board
GND: U8.1, U8.5, U8.6, U9.2 (GND); also elsewhere on the board
unnamed: U8.3, U9.1 (I/O1)
unnamed: U8.4, U9.3 (I/O2)

Parts:
LED1: XL-1615RGBC-RF; LED-ARRAY-SMD_4P-L1.6-W1.5-BR_XL-1615RGBC-RF; LCSC Part C965840
R6, R8: 2k; R_0402_1005Metric; LCSC C4109
R7: 10k; R_0402_1005Metric; LCSC C25744

Connections:
+3V3: LED1.2 (COM+); also elsewhere on the board
LED_BLUE: R8.2; also elsewhere on the board
LED_GREEN: R7.2; also elsewhere on the board
LED_RED: R6.1; also elsewhere on the board
unnamed: LED1.3 (B-), R8.1
unnamed: LED1.4 (G-), R7.1
unnamed: LED1.1 (R-), R6.2

Parts:
AE1: Antenna_Dipole; NFC_2.8uH_COIL; not fitted
C20, C59, C65: C_0402_1005Metric; not fitted
C42, C43: 68pF; C_0402_1005Metric; LCSC C389103
R29, R30: 0; R_0402_1005Metric; LCSC C17168

Connections:
/NFC Antenna/NFC1: R29.2; also elsewhere on the board
/NFC Antenna/NFC2: R30.2; also elsewhere on the board
GND: C20.1, C42.2, C43.1, C59.1; also elsewhere on the board
unnamed: AE1.1, C42.1, C59.2, C65.1, R30.1
unnamed: AE1.2, C20.2, C43.2, C65.2, R29.1

Notes on the sheet:
nRF52840_P_v1.10 Page 461 NFC Antenna spec, 13.56 MHz
TODO: Tune on prototype current capacitance too low.
The two capacitors must form a tuned circuit at 13.56MHz together with the antenna coil. TODO: design antenna footprint, get inductiance and match capacitors.

Parts:
C32: 4.7uF; C_0603_1608Metric; LCSC C69335
C33, C34, C35, C37, C38, C39, C40: 1uF; C_0603_1608Metric; LCSC C5199872
C36: 1uF; C_0603_1608Metric; LCSC C15849; not fitted
C41: 470nF; C_0603_1608Metric; LCSC C1623
D3, D5, D8: B0530WS; D_SOD-323; LCSC C22466873
FPC2: 0.5-24P CTSJ-H2.0 119; FPC-SMD_24P-P0.50_SHOU-HAN_CTSJ-H2.0; LCSC Part C2858299
L9: 47uH; L_1210_3225Metric; LCSC C83083
Q2: AP2302B; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; LCSC C406812
R11: 2.2; R_0805_2012Metric; LCSC C2907304
R12: 100k; R_0402_1005Metric; LCSC C25741
R13: 0; R_0402_1005Metric; not fitted

Connections:
+3V3: C32.2, FPC2.9, FPC2.10, L9.1, R13.1; also elsewhere on the board
/DISPLAY/GDR: FPC2.23, Q2.1 (G), R12.2
/DISPLAY/PREVGH: C35.2, D8.1 (K), FPC2.4
/DISPLAY/PREVGL: C34.1, D3.2 (A), FPC2.2
/DISPLAY/RESE: FPC2.22, Q2.2 (S), R11.2
/DISPLAY/VCOM: C41.2, FPC2.1
/DISPLAY/VGH: C37.2, FPC2.20
/DISPLAY/VGL: C36.2, FPC2.21
/DISPLAY/VSH: C39.2, FPC2.5
/DISPLAY/VSL: C40.2, FPC2.3
/EPD_BUSY: FPC2.16; also elsewhere on the board
/EPD_CSN: FPC2.13; also elsewhere on the board
/EPD_DC: FPC2.14; also elsewhere on the board
/EPD_MOSI: FPC2.11; also elsewhere on the board
/EPD_RESET: FPC2.15; also elsewhere on the board
/EPD_SCK: FPC2.12; also elsewhere on the board
GND: C32.1, C34.2, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, D5.1 (K), FPC2.8, FPC2.17, FPC2.25, FPC2.26, R11.1, R12.1; also elsewhere on the board
unnamed: C38.2, FPC2.7, R13.2
unnamed: C33.1, D3.1 (K), D5.2 (A)
unnamed: C33.2, D8.2 (A), L9.2, Q2.3 (D)

Notes on the sheet:
Diode requirements Vrev > 30V Io > 500mA Vfw < 430mV
VDDIO
Pin numbering of connector is reversed compared to display datasheet
VPP
VDD
Schematic Page 12 https://cdn-learn.adafruit.com/assets/assets/000/097/631/original/SSD1680_Datasheet.pdf?1607625960
VSS
BS1
VCI
