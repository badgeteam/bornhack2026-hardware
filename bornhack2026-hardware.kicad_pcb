# Repository badgeteam/bornhack2026-hardware (continued)

## KiCad design bornhack2026-hardware.kicad_pcb (continued)

Parts:
AE2: Antenna; Texas_SWRA117D_2.4GHz_Right; not fitted
C2, C6: 18pF; C_0402_1005Metric; LCSC C1549
C3, C4: 12pF; C_0402_1005Metric; LCSC C1547
C5: .5pF; C_0402_1005Metric; LCSC C1544
C7: .8pF; C_0402_1005Metric; LCSC C285068
C8, C15, C18, C44: 2.2uF; C_0402_1005Metric; LCSC C12530
C10, C58, C68: 100nF; C_0402_1005Metric; LCSC C1525
C11: 100pF; C_0402_1005Metric; LCSC C1546; not fitted
C12: 100pF; C_0402_1005Metric; LCSC C1546
C13: 820pF; C_0402_1005Metric; LCSC C1543
C14: 100nF; C_0402_1005Metric; LCSC C1525; not fitted
C16, C17: 4.7uF; C_0402_1005Metric; LCSC C23733
C73: 47nF; C_0402_1005Metric; LCSC C82219
C74: 1uF; C_0402_1005Metric; LCSC C52923
J4: Conn_02x05_Odd_Even; PinHeader_2x05_P1.27mm_Vertical_SMD; LCSC C27985146
L2: 4.7nH; L_0402_1005Metric; LCSC C86065
L3: 10uH; L_0603_1608Metric; LCSC C1035
L14: 15nH; L_0402_1005Metric; LCSC C381880
NT3: NetTie_2; NetTie-2_SMD_Pad0.5mm; not fitted
R3, R4, R17: 0; R_0402_1005Metric; LCSC C17168
R36, R37, R38: 10k; R_0402_1005Metric; LCSC C25744; not fitted
RF3: A-IPEX1-1.25A; IPEX-SMD_3P-L2.6-W2.6-LS3.0_RF1200001R; LCSC Part C22467595
TP1: GND; TestPoint_Pad_D1.0mm; not fitted
TP2: SWDCLK; TestPoint_Pad_D1.0mm; not fitted
TP3: SWO; TestPoint_Pad_D1.0mm; not fitted
TP4: SWDIO; TestPoint_Pad_D1.0mm; not fitted
U5: ZD25WQ16CTIGT; SOIC-8_L4.9-W3.9-P1.27-LS6.0-BL; LCSC Part C5353550
U6: NRF52840-QIAA-R; XCVR_NRF52840-QIAA-R; PARTREV v1.1; LCSC C190794
U7: USBLC6-2P6; SOT-666; LCSC C22390016
X1: S201632M10PF10PPM 32MHz; CRYSTAL-SMD_4P-L2.0-W1.6-BL; LCSC Part C7420782
X3: 32.768KHz; Crystal_SMD_3215-2Pin_3.2x1.5mm; LCSC C95361

Connections:
+3V3: C8.1, C15.1, C18.1, C44.1, C58.1, C68.1, J4.1, R36.2, R38.2, U5.8 (VCC), U6.A22 (VDD), U6.AD14 (VDD), U6.AD23 (VDD), U6.B1 (VDD), U6.W1 (VDD), U6.Y2 (VDDH); also elsewhere on the board
/BAT_CHARGE: U6.K2 (P0.05/AIN3); also elsewhere on the board
/BTN_CANCEL: U6.L1 (P0.06); also elsewhere on the board
/BTN_EXECUTE: U6.G1 (P0.26); also elsewhere on the board
/BUZZER: U6.AD8 (P0.13); also elsewhere on the board
/EPD_BUSY: U6.AC9 (P0.14); also elsewhere on the board
/EPD_CSN: U6.R1 (P1.09/TRACEDATA3); also elsewhere on the board
/EPD_DC: U6.U1 (P0.12/TRACEDATA1); also elsewhere on the board
/EPD_MOSI: U6.H2 (P0.27); also elsewhere on the board
/EPD_RESET: U6.T2 (P0.11/TRACEDATA2); also elsewhere on the board
/EPD_SCK: U6.N1 (P0.08); also elsewhere on the board
/GPIO_1: U6.AD10 (P0.15); also elsewhere on the board
/GPIO_2: U6.AC11 (P0.16); also elsewhere on the board
/GPIO_3: U6.AC15 (P0.19); also elsewhere on the board
/GPIO_4: U6.P2 (P1.08); also elsewhere on the board
/JOY_DOWN: U6.V23 (P1.03); also elsewhere on the board
/JOY_FIRE: U6.W24 (P1.02); also elsewhere on the board
/JOY_LEFT: U6.T23 (P1.05); also elsewhere on the board
/JOY_RIGHT: U6.Y23 (P1.01); also elsewhere on the board
/JOY_UP: U6.U24 (P1.04); also elsewhere on the board
/LORA_BUSY: U6.B11 (P0.28/AIN4); also elsewhere on the board
/LORA_DIO1: U6.A10 (P0.29/AIN5); also elsewhere on the board
/LORA_MISO: U6.B13 (P0.03/AIN1); also elsewhere on the board
/LORA_MOSI: U6.B15 (P1.14); also elsewhere on the board
/LORA_NSS: U6.B17 (P1.12); also elsewhere on the board
/LORA_RF_SW: U6.J1 (P0.04/AIN2); also elsewhere on the board
/LORA_RST: U6.B9 (P0.30/AIN6); also elsewhere on the board
/LORA_SCK: U6.A16 (P1.13); also elsewhere on the board
/MCU_RESETn: J4.10, U6.AC13 (P0.18/NRESET); also elsewhere on the board
/NFC Antenna/NFC1: U6.L24 (P0.09/NFC1); also elsewhere on the board
/NFC Antenna/NFC2: U6.J24 (P0.10/NFC2); also elsewhere on the board
/NRF52840_MCU/DCC: L3.2, U6.B3 (DCC)
/NRF52840_MCU/DEC1: C10.2, U6.C1 (DEC1)
/NRF52840_MCU/DEC2: C14.2, U6.A18 (DEC2)
/NRF52840_MCU/DEC3: C12.2, U6.D23 (DEC3)
/NRF52840_MCU/DEC4: C11.2, C73.1, C74.2, L14.1, U6.B5 (DEC4), U6.E24 (DEC6)
/NRF52840_MCU/DEC5: C13.2, U6.N24 (DEC5)
/NRF52840_MCU/DECUSB: C17.1, U6.AC5 (DECUSB)
/NRF52840_MCU/DIODE_USB_D+: R3.2, U7.1 (I/O1)
/NRF52840_MCU/DIODE_USB_D-: R4.2, U7.3 (I/O2)
/NRF52840_MCU/NRF_USB_D+: R3.1, U6.AD6 (D+)
/NRF52840_MCU/NRF_USB_D-: R4.1, U6.AD4 (D-)
/NRF52840_MCU/P0.20_QSPI_SIO_0: U5.5 (SI/IO0), U6.AD16 (P0.20)
/NRF52840_MCU/P0.21_QSPI_SCK: U5.6 (SCLK), U6.AC17 (P0.21)
/NRF52840_MCU/P0.22_QSPI_SIO_2: U5.3 (~WP/IO2), U6.AD18 (P0.22)
/NRF52840_MCU/P0.23_QSPI_SIO_3: U5.7 (~HOLD/IO3), U6.AC19 (P0.23)
/NRF52840_MCU/P0.24_QSPI_SIO_1: U5.2 (SO/IO1), U6.AD20 (P0.24)
/NRF52840_MCU/P0.25_QSPI_CSN: U5.1 (~CS), U6.AC21 (P0.25)
/NRF52840_MCU/P1.00_SWO: J4.6, R38.1, TP3.1 (1_1), U6.AD22 (P1.00/TRACEDATA0)
/PS_SYNC: U6.AD12 (P0.17); also elsewhere on the board
/QWIIC_SCL: U6.B19 (P1.11); also elsewhere on the board
/QWIIC_SDA: U6.A20 (P1.10); also elsewhere on the board
/USB_D+: U7.6 (I/O1); also elsewhere on the board
/USB_D-: U7.4 (I/O2); also elsewhere on the board
ANT: C7.1, L2.2, U6.H23 (ANT)
BAT_V: U6.A8 (P0.31/AIN7); also elsewhere on the board
BAT_V_READ: U6.M2 (P0.07/TRACECLK); also elsewhere on the board
GND: AE2.2, C2.2, C3.1, C4.1, C5.2, C6.2, C8.2, C10.1, C11.1, C12.1, C13.1, C14.1, C15.2, C16.2, C17.2, C18.2, C44.2, C58.2, C68.2, C73.2, C74.1, J4.3, J4.5, J4.9, NT3.1, R37.1, RF3.2, RF3.3, TP1.1 (1_1), U5.4 (VSS), U6.74 (VSS), U6.B7 (VSS), U7.2 (GND), X1.2, X1.4; also elsewhere on the board
LED_BLUE: U6.A12 (P0.02/AIN0); also elsewhere on the board
LED_GREEN: U6.A14 (P1.15); also elsewhere on the board
LED_RED: U6.P23 (P1.07); also elsewhere on the board
unnamed: AE2.1, R17.1
unnamed: C5.1, L2.1, R17.2, RF3.1
unnamed: L3.1, L14.2
SWDCLK: J4.4, R37.2, TP2.1 (1_1), U6.AA24 (SWDCLK)
SWDIO: J4.2, R36.1, TP4.1 (1_1), U6.AC24 (SWDIO)
VBUS: C16.1, U6.AD2 (VBUS), U7.5 (VBUS); also elsewhere on the board
VSS_PA: C7.2, NT3.2, U6.F23 (VSS_PA)
XC1: C6.1, U6.B24 (XC1), X1.3
XC2: C2.1, U6.A23 (XC2), X1.1
XL1: C3.2, U6.D2 (P0.00/XL1), X3.1
XL2: C4.2, U6.F2 (P0.01/XL2), X3.2

Notes on the sheet:
SWD debug interface
32MHz
RTC clock oscillator
32.768KHz
Bluetooth antenna Implementing: https://www.lcsc.com/datasheet/C127620.pdf
Main MCU Clock oscillator
Power circuit Datasheet: 7.3.5 configuration 5

Schematic: buzzer.kicad_sch

Parts:
BUZZER1: MLT-8530; BUZ-SMD_4P-L8.5-W8.5-P8.50-BR; LCSC Part C94599
C1: 1uF; C_0603_1608Metric; LCSC C5199872
D4: 1N5819WS; D_SOD-323; LCSC C191023
Q3: SI2302_C5296725; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; LCSC C5296725
R39, R40: 1M; R_0402_1005Metric; LCSC C26083
R41, R47: 100; R_0402_1005Metric; LCSC C25076

Connections:
+3V3: BUZZER1.1 (+), D4.1 (K); also elsewhere on the board
/BUZZER: C1.2, R39.1; also elsewhere on the board
GND: BUZZER1.3, BUZZER1.4, Q3.2 (S), R39.2, R40.1; also elsewhere on the board
unnamed: BUZZER1.2, D4.2 (A), R41.2, R47.2
unnamed: Q3.3 (D), R41.1, R47.1
unnamed: C1.1, Q3.1 (G), R40.2

Schematic: sx1262.kicad_sch, Bornhack 2026

Parts:
C22: 470nF; C_0603_1608Metric; LCSC C1623
C24: 100nF; C_0402_1005Metric; LCSC C1525
C25: 47nF; C_0402_1005Metric; LCSC C82219
C26, C29: 47pF; C_0402_1005Metric; LCSC C472454
C27, C28: 1nF; C_0402_1005Metric; LCSC C1523
C30, C50: 1.8pF; C_0402_1005Metric; LCSC C22374861
C31: 3.6pF; C_0402_1005Metric; LCSC C161321; not fitted
C45: 3.3pF; C_0402_1005Metric; LCSC C2941931
C46, C52: C_Small; C_0402_1005Metric; not fitted
C47: 5.6pF; C_0402_1005Metric; LCSC C16193755
C48: 39pF; C_0402_1005Metric; LCSC C86288
C49: 2.2pF; C_0402_1005Metric; LCSC C325452
C51: 2.4pF; C_0402_1005Metric; LCSC C48346
C53: 1uF; C_0603_1608Metric; LCSC C5199872
L5: 15uH; L_0603_1608Metric; LCSC C486329
L6: 47nH; L_0402_1005Metric; LCSC C27151
L7: 2.5nH; L_0402_1005Metric; LCSC C778764
L8: 7.5nH; L_0402_1005Metric; LCSC C98001
L10: 4.7nH; L_0402_1005Metric; LCSC C86065
L11: 0; L_0402_1005Metric; LCSC C17168
L12: 15nH; L_0402_1005Metric; LCSC C381880
R9, R10: 100; R_0402_1005Metric; LCSC C25076
R31, R32: 0; R_0402_1005Metric; LCSC C17168
RF1: A-IPEX1-1.25A; IPEX-SMD_3P-L2.6-W2.6-LS3.0_RF1200001R; LCSC Part C22467595
U2: ZHHXDZ HXCKRF2179MM26-C4; SOT-363-6_L2.0-W1.3-P0.65-LS2.1-BL; LCSC C49010109
U3: SX1262IMLTRT; QFN-24_L4.0-W4.0-P0.50-BL-EP2.6; LCSC Part C191341
X2: S201632M10PF10PPM 32MHz; CRYSTAL-SMD_4P-L2.0-W1.6-BL; LCSC Part C7420782

Connections:
+3V3: C24.2, C53.1, U3.1 (VDD_IN), U3.10 (VBAT), U3.11 (VBAT_IO); also elsewhere on the board
/LORA_BUSY: U3.14 (BUSY); also elsewhere on the board
/LORA_DIO1: U3.13 (DIO1); also elsewhere on the board
/LORA_MISO: U3.16 (MISO); also elsewhere on the board
/LORA_MOSI: U3.17 (MOSI); also elsewhere on the board
/LORA_NSS: U3.19 (NSS); also elsewhere on the board
/LORA_RF_SW: R9.1; also elsewhere on the board
/LORA_RST: U3.15 (NRESET); also elsewhere on the board
/LORA_SCK: U3.18 (SCK); also elsewhere on the board
/SX1262 LoRA/DIO2: R10.1, U3.12 (DIO2)
/SX1262 LoRA/LORA_ANT: C31.1, L8.2; also elsewhere on the board
/SX1262 LoRA/XTA: U3.3 (XTA), X2.1
/SX1262 LoRA/XTB: U3.4 (XTB), X2.3
GND: C22.2, C24.1, C25.2, C26.2, C27.2, C28.2, C30.2, C31.2, C46.1, C47.2, C49.2, C50.1, C52.1, C53.2, RF1.2, RF1.3, U2.2 (GND), U3.2 (GND), U3.5 (GND), U3.8 (GND), U3.20 (GND), U3.25 (GND), X2.2 (GND), X2.4 (GND); also elsewhere on the board
unnamed: C29.1, R31.2
unnamed: C29.2, C30.1, L8.1
unnamed: C45.1, C46.2, L6.2, L7.1, L11.2
unnamed: C45.2, C47.1, C48.1, L7.2
unnamed: C48.2, L10.1
unnamed: R31.1, R32.2, RF1.1
unnamed: C51.1, C52.2, U2.3 (RF1)
unnamed: C49.1, L10.2, U2.1 (RF2)
unnamed: R32.1, U2.5 (RFC)
unnamed: C28.1, R10.2, U2.4 (VC1)
unnamed: C27.1, R9.2, U2.6 (VC2)
unnamed: L5.2, U3.9 (DCC_SW)
unnamed: C51.2, L12.2, U3.22 (RFI_N)
unnamed: C50.2, L12.1, U3.21 (RFI_P)
unnamed: L11.1, U3.23 (RFO)
unnamed: C22.1, L5.1, U3.7 (VREG)
unnamed: C25.1, C26.1, L6.1, U3.24 (VR_PA)

Notes on the sheet:
TODO: Implement the switchless design, because cheaper
Reference design AN1200.54 BOM page 19
DC-DC SW @ 3.25MHz
https://www.ti.com/lit/an/swra496a/swra496a.pdf?ts=1771785552812 Page 35/36 Matching circuit 50 Ohm RF source to antenna
AN1200.91 Layout reference Page 5
Main MCU Clock oscillator
LORA_RF_SW1, LOW = RF2 -> RFC

Schematic: gen_button.kicad_sch, Bornhack 2026

Parts:
C60: 100nF; C_0402_1005Metric; LCSC C1525
R19: 10k; R_0402_1005Metric; LCSC C25744
SW6: TS3425PA 160GF 098; KEY-SMD_2P-L6.0-W6.0-P6.00; LCSC Part C115348

Connections:
+3V3: R19.1; also elsewhere on the board
/BTN_EXECUTE: C60.2, R19.2, SW6.2; also elsewhere on the board
GND: C60.1, SW6.1; also elsewhere on the board

Parts of its further copies:
C61: 100nF; C_0402_1005Metric; LCSC C1525
R21: 10k; R_0402_1005Metric; LCSC C25744
SW8: TS3425PA 160GF 098; KEY-SMD_2P-L6.0-W6.0-P6.00; LCSC Part C115348

Connections of its further copies:
+3V3: R21.1; also elsewhere on the board
/BTN_CANCEL: C61.2, R21.2, SW8.2; also elsewhere on the board
GND: C61.1, SW8.1; also elsewhere on the board

Board: 4 copper layers, 67.4 x 89.9 mm, 193 parts (176 on the bottom side), 128 nets.

Other parts of the board:
kibuzzard-697FD34C: G***; kibuzzard-697FD34C
kibuzzard-697FD37D: G***; kibuzzard-697FD37D
kibuzzard-697FD333: G***; kibuzzard-697FD333
kibuzzard-69569E9F: G***; kibuzzard-69569E9F

File production/cyber-egg-2025-02-20_bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BUZZER1,BUZ-SMD_4P-L8.5-W8.5-P8.50-BR,1,MLT-8530,C94599
"C1, C33, C34, C35, C37, C38, C39, C40, C53, C72",0603,10,1uF,C5199872
"C10, C24, C55, C58, C60, C61, C62, C63, C64, C68, C69, C70",0402,12,100nF,C1525
C12,0402,1,100pF,C1546
C13,0402,1,820pF,C1543
"C15, C18, C44, C66, C67, C8",0402,6,2.2uF,C12530
"C16, C17",0402,2,4.7uF,C23733
"C19, C57",0603,2,22uF,C59461
"C2, C6",0402,2,18pF,C1549
"C22, C41",0603,2,470nF,C1623
"C25, C73",0402,2,47nF,C82219
"C26, C29",0402,2,47pF,C472454
"C27, C28",0402,2,1nF,C1523
"C3, C4",0402,2,12pF,C1547
"C30, C31",0402,2,3.6pF,C161321
C32,0603,1,4.7uF,C69335
"C42, C43",0402,2,68pF,C389103
C45,0402,1,3pF,C41361091
C47,0402,1,5.6pF,C16193755
C48,0402,1,39pF,C86288
"C49, C50",0402,2,1.8pF,C22374861
C5,0402,1,.5pF,C1544
C51,0402,1,2.4pF,C48346
"C54, C56, C9",0603,3,10uF,C19702
C7,0402,1,.8pF,C285068
C74,0402,1,1uF,C52923
CN1,FPC-SMD_24P-P0.50_TF31-24S-0.5SH,1,TF31-24S-0.5SH(800),C3169854
"D3, D5, D8",D_SOD-323,3,B0530WS,C22466873
"D4, D6, D7",D_SOD-323,3,1N5819WS,C191023
J1,USB_C_Receptacle_HRO_TYPE-C-31-M-12,1,USB device,C165948
J4,PinHeader_2x05_P1.27mm_Vertical_SMD,1,Conn_02x05_Odd_Even,C27985146
L1,L_Vishay_IFSC-1515AH_4x4x1.8mm,1,0.47uH A-sat 5.4 DCR 7.6 mOhm,C7497069
"L10, L2",0402,2,4.7nH,C86065
"L11, R17, R29, R3, R30, R31, R32, R4",0402,8,0,C17168
"L12, L14",0402,2,15nH,C381880
L3,0603,1,10uH,C1035
L5,0603,1,15uH,C486329
L6,0402,1,47nH,C27151
L7,0402,1,2.5nH,C778764
L8,0402,1,8.2nH,C98003
L9,1210,1,47uH,C83083
LED1,LED-ARRAY-SMD_4P-L1.6-W1.5-BR_XL-1615RGBC-RF,1,XL-1615RGBC-RF,C965840
Q1,SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR,1,JSM2301S,C916399
Q2,SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR,1,AP2302B,C406812
Q3,SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR,1,SI2302_C5296725,C5296725
"R1, R2",0402,2,5k1,C25905
"R10, R41, R9",0402,3,100,C25076
R11,0805,1,2.2,C2907304
"R12, R47, R5",0402,3,100k,C25741
"R14, R16",0402,2,1k,C11702
"R15, R18, R19, R21, R22, R23, R26, R27, R28, R7",0402,10,10k,C25744
"R25, R6, R8",0402,3,2k,C4109
"R34, R39, R40, R44",0402,4,1M,C26083
R35,0402,1,510k,C25564
"R42, R43",0402,2,4.7k,C25900
R45,0402,1,511k,C64042
R46,0402,1,91k,C4147
"RF1, RF3",IPEX-SMD_3P-L2.6-W2.6-LS3.0_RF1200001R,2,A-IPEX1-1.25A,C22467595
SW1,SW-SMD_4P-L5.1-W5.1-P3.70-LS6.5-TL_H1.5,1,RESET,C318884
SW2,SW-SMD_3P-P1.50_L2.7-W6.6,1,SK-3296S-01-L1,C319020
SW4,SW-SMD_6P-L7.0-W7.0-P1.40-LS7.4-TL,1,7*7*5-6P WX,C2858286
"SW6, SW8",KEY-SMD_2P-L6.0-W6.0-P6.00,2,TS3425PA 160GF 098,C115348
U1,CONN-SMD_PH-2AWB,1,PH-2AWB,C20598817
U10,DSBGA-15_L2.3-W1.3-R5-C3-P0.40-TL,1,TPS63805YFFR,C2879615
U2,SOT-363-6_L2.0-W1.3-P0.65-LS2.1-BL,1,ZHHXDZ HXCKRF2179MM26-C4,C49010109
U3,QFN-24_L4.0-W4.0-P0.50-BL-EP2.6,1,SX1262IMLTRT,C191341
U4,SOT-23-5_L2.9-W1.6-P0.95-LS2.8-BL,1,XT4054K421MR-G,C141405
U5,SOIC-8_L4.9-W3.9-P1.27-LS6.0-BL,1,ZD25WQ16CTIGT,C5353550
U6,XCVR_NRF52840-QIAA-R,1,NRF52840-QIAA-R,C190794
"U7, U9",SOT-666,2,USBLC6-2P6,C22390016
U8,CONN-SMD_HCZZ0032-4,1,HCZZ0032-4,C7433425
"X1, X2",CRYSTAL-SMD_4P-L2.0-W1.6-BL,2,S201632M10PF10PPM 32MHz,C7420782
X3,Crystal_SMD_3215-2Pin_3.2x1.5mm,1,32.768KHz,C95361

## Commit log (part)

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2025-12-24 Added luxury schematic for sx1262
2025-12-25 Fixed mistake in NRF52 footprint, add NAND FLASH, add NFC antenna schematic.
2025-12-26 Add original tamagotchi buttons to schematic.
2025-12-26 PCB layout egg shape, for reference.
2025-12-27 Switched the LC filters from ceramic LoRa filter.
2025-12-28 Progress, routed more stuff.
2025-12-29 Bluetooth antenna should work better, NFC has IPEX for tuning.
2025-12-29 Wired in display
2025-12-29 Redid the sx1268 RF circuit for the layout to comply with the datasheet.
2025-12-29 small fixes.
2025-12-30 Routed buttons to MCU.
2025-12-30 Fixed DRC errors, added bunch of stitch through vias.
2025-12-30 Fix tiny issues, add more vias.
2025-12-31 Moved SMA-connector Lora for VNA testing.
2026-01-01 WIP: Moved buttons, battery.
2026-01-01 Connected up buttons, labeled buttons, added some via stitching.
2026-01-01 Add JTAG 2.54mm header footprint.
2026-01-01 Remove mounting hole REFDES.
2026-01-01 Add missing board edge symbol.
2026-01-01 Check & fix MCU schematic
2026-01-02 Processed the unconnected pads in the NRF52 Renze found, Added the IPEX connector to allow tuning of the Bluetooth antenna, moved the RESET button.
2026-01-02 Moved battery connector out of the way of the battery.
2026-01-02 Checked PCBA for JLCPCB.
2026-01-03 Changed antennas for PCB antennas, move stuff because of it.
2026-01-03 Changed NFC coil + tune C's to match better with datasheet.
2026-01-04 Moved LoRa radio closer to antenna
2026-01-04 Remove old prod files.
2026-01-04 Added small Bornhack logo.
2026-01-04 Display
2026-01-04 Fix display connector 3D model
2026-01-04 Badge.Team
2026-01-04 Fix screen outline (that I broke), add epaper 3D model back in, move flat cable hole down a bit.
2026-01-04 Squashed in new battery connector, made NFC coil and Bluetooth fit as good and bad as possible.
2026-01-04 Clean up NFC connection.
2026-01-04 Fixed missing NRF52 3D object and missing connection.
2026-01-04 Add QWIIC connector to design.
2026-01-06 Replaced joystick with alternatie (cheaper) part.
2026-01-06 Add batteryvoltage and charge indicator circuit.
2026-01-07 Fixed schematic enspect errors. Fixed jhaand name in silk screen.
2026-01-07 Added some PCB art.
2026-01-07 Cleaned up pinout
2026-01-07 Add Readme, fix labels in schematic.
2026-01-07 Finish table.
2026-01-09 10-pin SWD interface added.
2026-01-10 Moved SWR connector to other side of board, reversed on/off switch UP -> ON.
2026-01-10 Fixed PCBA rotations in using component property.
2026-01-10 Fix missing epaper display in 3D models.
2026-01-12 Added buzzer to the design.
2026-01-13 Add Readme text, fixed some stuff in the design again, pull-ups externally on the I2C bus.
2026-01-13 Add Readme + badge images.
2026-01-18 Optimized design to use more basic components.
2026-01-19 Fixed DRC errors, added the game.
2026-01-19 Fixed nmos part that was not sufficiently in stock at LCSC.
2026-01-22 Module version with ra-01sh LoRa
2026-01-24 Replaced schottky diode with 1A version, fixed joystick footprint.
2026-01-25 Diodes in spec now for the display driver.
2026-01-26 Small cleanups.
2026-02-04 Add capacitors, add DC pin to epaper-display.
2026-02-07 Tuning capacitors NRF 22pF 13.5MHz
2026-02-09 On to proto v2.
2026-02-12 Add ESD protoction to USB-C, small fixes
2026-02-16 Improvements, now need to know the specs for the new display module.
2026-02-19 Switched to recycled e-ink screen, using the Tanoshii measuremens and distances.
2026-02-19 Fixed net names of changed pins
2026-02-21 Changed out RF switch and display connector for parts that are stil available.
2026-02-21 Fix power supply, use PG signal to hold reset until the power is stable.
2026-02-22 Fixed schematic to have 0 DRC errors, changed display connector.
2026-02-22 Fixed some more DRC errors in PCB.
2026-02-23 Add MA logo, test points, tuned RF LoRa.
2026-02-26 Artwork added, minor rework on the LoRa rf component placement.
2026-02-26 dotting the i's , list checks before V2 order.
2026-02-27 Add todo for updating pinout table.
2026-02-27 Prototype V2 production files added.
2026-03-08 Updated readme.md for Prototype V2. Simplified NRF IO net names.
2026-03-14 Prototype V2 hardware fixes, clearance SWD port, move display up. Add seagull to front silkscreen.
2026-03-15 Update to Prototype V2 screenshots in Readme.
2026-04-25 Prototype V3, speaker resistor 50 ohm, 500ohm on to second pad epd
2026-05-16 Gold master before production v1
2026-06-20 Version sent to allnet.
2026-06-20 Fixed version, badger back in cage.
2026-06-28 Changes for the SSD1681
