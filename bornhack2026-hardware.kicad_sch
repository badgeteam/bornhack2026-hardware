File: bornhack2026-hardware.kicad_sch (KiCad schematic)
At the start: 10 parts, among them J1 USB device

Commit message: Fixed PCBA rotations in using component property.
Other:
- sheet DISPLAY ports: added RESETn; removed RESET
- sheet INPUT ports: added BTN_RESETn; removed BTN_RESET
- sheet NRF52840_MCU ports: added RESETn; removed RESET
- moved on the sheet: AE3

Commit message: Added buzzer to the design.
Connections:
- no-connect marks 16 -> 15
Other:
- added sheet Buzzer (buzzer.kicad_sch)
Changed lines of the file:
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@@
 	)
 	(no_connect
-		(at 137.16 78.74)
-	)
-	(no_connect
 		(at 137.16 106.68)
 	)
@@
 	(wire
 		(pts
+			(xy 116.84 78.74) (xy 137.16 78.74)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 99.06 158.75) (xy 76.2 158.75)
 		)
@@
 	(wire
 		(pts
+			(xy 167.64 143.51) (xy 187.96 143.51)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 201.93 87.63) (xy 180.34 87.63)
 		)
@@
 		)
 	)
+	(label "P0.13_BUZZ_IN"
+		(at 116.84 78.74 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify left bottom)
+		)
+	)
 	(label "P0.12_DSP_RESETn"
 		(at 81.28 130.81 180)
@@
 		)
 	)
+	(label "P0.13_BUZZ_IN"
+		(at 167.64 143.51 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify left bottom)
+		)
+	)
 	(label "P1.09_DSP_CSN"
 		(at 81.28 118.11 180)
@@
 				)
 			)
+		)
+	)
+	(sheet
+		(at 187.96 137.16)
+		(size 29.21 12.065)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
+		(fields_autoplaced yes)
+		(stroke
+			(width 0.1524)
+			(type solid)
+		)
+		(fill
+			(color 0 0 0 0.0000)
+		)
+		(property "Sheetname" "Buzzer"
+			(at 187.96 136.4484 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left bottom)
+			)
+		)
+		(property "Sheetfile" "buzzer.kicad_sch"
+			(at 187.96 149.8096 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left top)
+			)
+		)
+		(pin "BUZ_IN" input
+			(at 187.96 143.51 180)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
+			)
+		)
+		(instances
+			(project "bornhack2026-hardware"
+				(path "/23bf5400-d19c-445b-8744-b63ebcca303d"
+					(page "12")
+				)
+			)

Commit message: Optimized design to use more basic components.
Parts:
- added J2: Conn_01x06_Pin, Connector_PinHeader_1.00mm:PinHeader_1x06_P1.00mm_Vertical_SMD_Pin1Left, symbol Connector:Conn_01x06_Pin
- H1, H2, H3: now not fitted
- N1, N2, N3: symbol Mechanical:Housing -> lcsc:Housing; now in the parts list
Connections:
- net +3V3: now also J2.5 (Pin_5)
- net GND: now also J2.6 (Pin_6)
- new net P0.14_EXP1: J2.1 (Pin_1)
- new net P0.14_EXP2: J2.2 (Pin_2)
- new net P0.14_EXP3: J2.3 (Pin_3)
- new net P0.14_EXP4: J2.4 (Pin_4)
- no-connect marks 15 -> 11
Other:
- note added: "Expansion port"
