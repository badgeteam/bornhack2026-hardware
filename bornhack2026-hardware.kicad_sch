File: bornhack2026-hardware.kicad_sch (KiCad schematic)
At the start: 10 parts, among them J1 USB device

Commit message: Fixed schematic enspect errors. Fixed jhaand name in silk screen.
Parts:
- J1: symbol mch2021-rescue:USB_C_Receptacle_USB2.0-Connector -> Connector:USB_C_Receptacle_USB2.0_16P
Changed lines of the file:
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@@
 	(wire
 		(pts
-			(xy 264.16 109.22) (xy 266.7 109.22)
+			(xy 264.16 109.22) (xy 273.05 109.22)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 266.7 109.22) (xy 266.7 106.68)
+			(xy 273.05 109.22) (xy 273.05 106.68)
 		)
 		(stroke
@@
 				(justify left)
 				(hide yes)
+			)
+		)
+	)
+	(netclass_flag ""
+		(length 2.54)
+		(shape round)
+		(at 265.43 109.22 0)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify left bottom)
+		)
+		(property "Netclass" "Power"
+			(at 266.1285 106.68 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
+			)
+		)
+		(property "Component Class" ""
+			(at -52.07 -12.7 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+					(italic yes)
+				)
 			)
 		)
@@
 	(symbol
 		(lib_id "power:VBUS")
-		(at 266.7 106.68 0)
+		(at 273.05 106.68 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(dnp no)
 		(property "Reference" "#PWR06"
-			(at 266.7 110.49 0)
+			(at 273.05 110.49 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "VBUS"
-			(at 266.7 102.87 0)
+			(at 273.05 102.87 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" ""
-			(at 266.7 106.68 0)
+			(at 273.05 106.68 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" ""
-			(at 266.7 106.68 0)
+			(at 273.05 106.68 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Power symbol creates a global label with name \"VBUS\""
-			(at 266.7 106.68 0)
+			(at 273.05 106.68 0)
 			(effects
 				(font
@@
 	)
 	(symbol
-		(lib_id "mch2021-rescue:USB_C_Receptacle_USB2.0-Connector")
+		(lib_id "Connector:USB_C_Receptacle_USB2.0_16P")
 		(at 248.92 124.46 0)
 		(unit 1)
@@
 			)
 		)
-		(property "Datasheet" "https://jlcpcb.com/partdetail/Korean_HropartsElec-TYPE_C_31_M12/C165948"
+		(property "Datasheet" "https://www.usb.org/sites/default/files/documents/usb_type-c.zip"
 			(at 252.73 124.46 0)
 			(effects
@@
 			)
 		)
-		(property "Description" "TYPE-C-31-M-12"
+		(property "Description" "USB 2.0-only 16P Type-C Receptacle connector"
 			(at 248.92 124.46 0)
 			(effects
@@
 			)
 		)
+		(pin "VBAT_READ" input
+			(at 262.89 30.48 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+			)
+		)
 		(pin "+3V3_OUT" output
 			(at 262.89 35.56 0)
 			(effects
 				(font
-					(size 1.27 1.27)
-				)
-				(justify right)
-			)
-		)
-		(pin "VBAT_READ" input
-			(at 262.89 30.48 0)
-			(effects
-				(font

Commit message: Cleaned up pinout
Other:
- sheet NRF52840_MCU ports: added P0.02/AIN0, P0.03/AIN1, P0.04/AIN1, P0.05/AIN2, P0.14, P0.28/AIN4, P0.29/AIN5, P0.30/AIN6, P0.31/AIN7; removed P0.02, P0.03, P0.04, P0.05, P0.14_READ_BAT, P0.28, P0.29, P0.30, P0.31

Commit message: Add Readme, fix labels in schematic.
Other:
- sheet INPUT ports: added P0.26_BTN_EXECUTE, P1.01_BTN_JOY_RIGHT, P1.02_BTN_JOY_FIRE, P1.03_BTN_JOY_DOWN, P1.04_BTN_JOY_UP, P1.05_BTN_JOY_LEFT; removed BTN_EXECUTE, BTN_JOY_DOWN, BTN_JOY_FIRE, BTN_JOY_LEFT, BTN_JOY_RIGHT, BTN_JOY_UP
- sheet POWER ports: added P1.08_CHRG; removed CHRG
- moved on the sheet: AE3, H1, H2, H3

Commit message: Moved SWR connector to other side of board, reversed on/off switch UP -> ON.
Other:
- sheet NRF52840_MCU ports: added P1.00_SWO; removed P1.00
Changed lines of the file:
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@@
 			)
 		)
-		(pin "P1.00" input
+		(pin "P1.00_SWO" input
 			(at 180.34 54.61 0)
 			(effects
